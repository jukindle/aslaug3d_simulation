Commit message: m

File: urdf/kallax/kallax_large.urdf (robot description, URDF)
Before this commit: robot floor_plane, 12 links, 11 joints
Joints:
- joint bottom_j: origin xyz=0 0.0185 rpy=0 0 0 -> xyz=0 0 0.0185 rpy=0 0 0
